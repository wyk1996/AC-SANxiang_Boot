# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: -AT32F403AVGT7 ArteryTek
  cpu: IRAM(0x20000000-0x20037FFF) IROM(0x08000000-0x080FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, __RTTHREAD__, AT32F403AVGT7, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\inc;..\libraries\f403a_407\rt_drivers;..\..\..\components\finsh;.;..\..\..\include;..\libraries\f403a_407\firmware\cmsis\cm4\device_support;..\libraries\f403a_407\firmware\cmsis\cm4\core_support;..\libraries\f403a_407\firmware\drivers\inc;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/ipc/: waitqueue.c ringblk_buf.c pipe.c ringbuffer.c workqueue.c dataqueue.c completion.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/src/: at32_msp.c board.c
    ../libraries/f403a_407/firmware/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
    ../libraries/f403a_407/rt_drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: clock.c object.c ipc.c mem.c thread.c components.c mempool.c irq.c device.c memheap.c kservice.c scheduler.c timer.c idle.c
  group Libraries
    ../libraries/f403a_407/firmware/drivers/src/: at32f403a_407_exint.c at32f403a_407_emac.c at32f403a_407_rtc.c at32f403a_407_spi.c at32f403a_407_dac.c at32f403a_407_bpr.c at32f403a_407_gpio.c at32f403a_407_sdio.c at32f403a_407_wdt.c at32f403a_407_usart.c at32f403a_407_flash.c at32f403a_407_dma.c at32f403a_407_pwc.c at32f403a_407_acc.c at32f403a_407_can.c at32f403a_407_crm.c at32f403a_407_crc.c at32f403a_407_wwdt.c at32f403a_407_debug.c at32f403a_407_usb.c at32f403a_407_adc.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_tmr.c at32f403a_407_xmc.c
    ../libraries/f403a_407/firmware/cmsis/cm4/device_support/: system_at32f403a_407.c
